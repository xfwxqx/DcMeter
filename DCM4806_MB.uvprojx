# Keil uVision project DCM4806_MB.uvprojx, settings and files
target DCM4806_MB (ARM-ADS)
  device: NUC029LAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.9
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: DCM4806_MB +hex
  AfterMake: fromelf --bincombined ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\DcMeter_Mini58;.\Library\inc;.\CMSIS;.\User;.\Device
  asm include: .\CMSIS
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./CMSIS/: system_NUC029xAN.c startup_NUC029xAN.s
  group Library
    ./Library/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c ebi.c
  group User
    ./User/: main.c Usart.c RN8209C.c PCF8563.c UserCommon.c AT45DBXXX.c Ydt1363.c NRX8010.c
